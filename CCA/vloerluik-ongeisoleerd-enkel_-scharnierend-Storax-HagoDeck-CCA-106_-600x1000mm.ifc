Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 240fac33-b9ff-46bf-ac48-02907a7f55e5.ifc
Time: 2026-09-11T10:53:31
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - HagoDeck CCA 106, 600x1000mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAP0KO9ADAAAAuFgBAAV2SgAA2FMBAInDAADxgwAAIVkBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAP0KO9ADAAAAuFgBAAV2SgAA2FMBAInDAADxgwAAIVkBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 17 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 740 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 1120 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 76,5 mm; merk: Storax; breuklast: A15; type: CCA 106; dagmaatbreedte: 1000 mm; omranding: aluminium; luik: aluminium
